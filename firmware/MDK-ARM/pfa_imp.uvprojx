# Keil uVision project pfa_imp.uvprojx, settings and files
target pfa_imp (6230000::V6.23::ARMCLANG)
  device: STM32F103RE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x00010000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M3") CLOCK(64000000) ELITTLE
  output: pfa_imp
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=3 v6LangP=1 wLevel=2
  c define: STM32F103xE,HSE_VALUE=16000000
  c misc: -Wall -Wextra -Wpedantic -Wshadow -Wconversion -Wdouble-promotion -Werror -ffunction-sections -fdata-sections -fno-common -isystem ../third_party/cmsis_core/Include -isystem ../third_party/cmsis_device_f1/Include
  c include: ..\app\include;..\bsp\include
  asm define: STM32F103xE,HSE_VALUE=16000000
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  scatter file: .\pfa_imp.sct
  link misc: --entry=Reset_Handler --keep=startup_stm32f103xe.o(.isr_vector)
  group app
    ../app/src/: main.c
  group bsp
    ../bsp/src/: bsp_board.c
  group cmsis_device_f1
    ../third_party/cmsis_device_f1/Source/Templates/: system_stm32f1xx.c
  group startup
    ../startup/: startup_stm32f103xe.S
